## Kconfig
```kconfig
config PMW3320
    bool "PixArt PMW3320 trackball sensor driver"
    default y
    depends on SPI
    select SENSOR
```
